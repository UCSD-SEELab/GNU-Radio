<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>WifiTest</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MTU</value></param>
<param><key>value</key><value>440</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>3000000</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>chan_est</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>labels</key><value>["LS", "LMS", "STA", "Linear Comb"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[ieee802_11.LS, ieee802_11.LMS, ieee802_11.STA, ieee802_11.COMB]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>encoding</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>labels</key><value>["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5, 6, 7]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq_1</value></param>
<param><key>value</key><value>2450000000</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_1_offset</value></param>
<param><key>value</key><value>-2000</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10000</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>10000</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq_2</value></param>
<param><key>value</key><value>2450000000</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_2_offset</value></param>
<param><key>value</key><value>4000</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10000</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>10000</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>6e6</value></param>
<param><key>option2</key><value>11e6</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3000000</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>/tmp/wifi.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>/tmp/wifi2.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.6</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>0.6</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0</value></param>
<param><key>istunflag</key><value>False</value></param>
<param><key>ifn</key><value>tap1</value></param>
<param><key>mtu</key><value>MTU</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0_0</value></param>
<param><key>istunflag</key><value>False</value></param>
<param><key>ifn</key><value>tap2</value></param>
<param><key>mtu</key><value>MTU</value></param>
</block>
<block>
<key>foo_packet_pad2</key>
<param><key>id</key><value>foo_packet_pad2_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
<param><key>pad_front</key><value>10000</value></param>
<param><key>pad_tail</key><value>10000</value></param>
</block>
<block>
<key>foo_packet_pad2</key>
<param><key>id</key><value>foo_packet_pad2_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
<param><key>pad_front</key><value>10000</value></param>
<param><key>pad_tail</key><value>10000</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>127</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>127</value></param>
</block>
<block>
<key>ieee802_11_ether_encap</key>
<param><key>id</key><value>ieee802_11_ether_encap_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_11_ether_encap</key>
<param><key>id</key><value>ieee802_11_ether_encap_0_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_11_mac</key>
<param><key>id</key><value>ieee802_11_mac_0</value></param>
<param><key>bss_mac</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
<param><key>dst_mac</key><value>[0x30, 0x14, 0x4a, 0xe6, 0x46, 0xe4]</value></param>
<param><key>src_mac</key><value>[0x12, 0x34, 0x56, 0x78, 0x90, 0xab]</value></param>
</block>
<block>
<key>ieee802_11_mac</key>
<param><key>id</key><value>ieee802_11_mac_0_0</value></param>
<param><key>bss_mac</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
<param><key>dst_mac</key><value>[0x30, 0x14, 0x4a, 0xe6, 0x46, 0xe4]</value></param>
<param><key>src_mac</key><value>[0x12, 0x34, 0x56, 0x78, 0x90, 0xab]</value></param>
</block>
<block>
<key>ieee802_11_parse_mac</key>
<param><key>id</key><value>ieee802_11_parse_mac_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>ieee802_11_parse_mac</key>
<param><key>id</key><value>ieee802_11_parse_mac_0_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>freq0</key><value>freq_1</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>freq0</key><value>freq_2</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>freq0</key><value>freq_1 + freq_1_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_0</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>freq0</key><value>freq_2 + freq_2_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>plot_tab</value></param>
<param><key>label0</key><value>RX</value></param>
<param><key>label1</key><value>TX</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>pluto_sink</key>
<param><key>id</key><value>pluto_sink_0</value></param>
<param><key>attenuation</key><value>10.0</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>cyclic</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>uri</key><value>ip:pluto.local</value></param>
<param><key>frequency</key><value>freq_1</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
</block>
<block>
<key>pluto_sink</key>
<param><key>id</key><value>pluto_sink_0_0</value></param>
<param><key>attenuation</key><value>10.0</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>cyclic</key><value>False</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>uri</key><value>ip:pluto.local</value></param>
<param><key>frequency</key><value>freq_2</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
</block>
<block>
<key>pluto_source</key>
<param><key>id</key><value>pluto_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>uri</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain</key><value>"manual"</value></param>
<param><key>frequency</key><value>freq_1 + freq_1_offset</value></param>
<param><key>manual_gain</key><value>rx_gain</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
</block>
<block>
<key>pluto_source</key>
<param><key>id</key><value>pluto_source_0_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>uri</key><value></value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain</key><value>"manual"</value></param>
<param><key>frequency</key><value>freq_2 + freq_2_offset</value></param>
<param><key>manual_gain</key><value>rx_gain</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>plot_tab@0</value></param>
<param><key>name</key><value>"Freq 1"</value></param>
<param><key>size</key><value>48*10</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>plot_tab@0</value></param>
<param><key>name</key><value>"Freq 2"</value></param>
<param><key>size</key><value>48*10</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>General</value></param>
<param><key>label1</key><value>Gains</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
<param><key>len_tag_name</key><value>packet_len</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
<param><key>len_tag_name</key><value>packet_len</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>wifi_phy_hier</key>
<param><key>id</key><value>wifi_phy_hier_0</value></param>
<param><key>bandwidth</key><value>samp_rate</value></param>
<param><key>chan_est</key><value>chan_est</value></param>
<param><key>encoding</key><value>encoding</value></param>
<param><key>frequency</key><value>freq_1</value></param>
<param><key>sensitivity</key><value>0.56</value></param>
</block>
<block>
<key>wifi_phy_hier</key>
<param><key>id</key><value>wifi_phy_hier_0_0</value></param>
<param><key>bandwidth</key><value>samp_rate</value></param>
<param><key>chan_est</key><value>chan_est</value></param>
<param><key>encoding</key><value>encoding</value></param>
<param><key>frequency</key><value>freq_2</value></param>
<param><key>sensitivity</key><value>0.56</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>foo_packet_pad2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>foo_packet_pad2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>wifi_phy_hier_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_0</source_block_id><sink_block_id>ieee802_11_ether_encap_0</sink_block_id><source_key>pdus</source_key><sink_key>from tap</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_0_0</source_block_id><sink_block_id>ieee802_11_ether_encap_0_0</sink_block_id><source_key>pdus</source_key><sink_key>from tap</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0</source_block_id><sink_block_id>pluto_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0_0</source_block_id><sink_block_id>osmosdr_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0_0</source_block_id><sink_block_id>pluto_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ether_encap_0</source_block_id><sink_block_id>blocks_tuntap_pdu_0</sink_block_id><source_key>to tap</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ieee802_11_ether_encap_0</source_block_id><sink_block_id>ieee802_11_mac_0</sink_block_id><source_key>to wifi</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>ieee802_11_ether_encap_0_0</source_block_id><sink_block_id>blocks_tuntap_pdu_0_0</sink_block_id><source_key>to tap</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ieee802_11_ether_encap_0_0</source_block_id><sink_block_id>ieee802_11_mac_0_0</sink_block_id><source_key>to wifi</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>ieee802_11_mac_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>phy out</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>ieee802_11_mac_0_0</source_block_id><sink_block_id>wifi_phy_hier_0_0</sink_block_id><source_key>phy out</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>wifi_phy_hier_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>wifi_phy_hier_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>carrier</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>mac_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>ieee802_11_ether_encap_0</sink_block_id><source_key>mac_out</source_key><sink_key>from wifi</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>ieee802_11_mac_0</sink_block_id><source_key>mac_out</source_key><sink_key>phy in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>ieee802_11_parse_mac_0</sink_block_id><source_key>mac_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0_0</sink_block_id><source_key>carrier</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0_0</source_block_id><sink_block_id>foo_wireshark_connector_0_0</sink_block_id><source_key>mac_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0_0</source_block_id><sink_block_id>ieee802_11_ether_encap_0_0</sink_block_id><source_key>mac_out</source_key><sink_key>from wifi</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0_0</source_block_id><sink_block_id>ieee802_11_mac_0_0</sink_block_id><source_key>mac_out</source_key><sink_key>phy in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0_0</source_block_id><sink_block_id>ieee802_11_parse_mac_0_0</sink_block_id><source_key>mac_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
